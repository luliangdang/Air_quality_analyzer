## libraries/Kconfig
```kconfig
config SOC_FAMILY_STM32
    bool

config SOC_SERIES_STM32F4
    bool
    select ARCH_ARM_CORTEX_M4
    select SOC_FAMILY_STM32
```
